# Keil uVision project usb_demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: usb_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./user/: main.c
  group app
    ./app/: led_driver.c time_driver.c key_driver.c uart_driver.c pdiusb.c
  group public
    ./public/: math.c
